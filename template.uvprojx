# Keil uVision project template.uvprojx, settings and files
target template (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\RTE;.\RTE\Device\STM32F407ZE;.\HARDWARE;.\USER;.\SYSTEM;.\FreeRTOS;.\FreeRTOS\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c
    ./: stm32f4xx_spi.c
  group HARDWARE
    ./HARDWARE/: led.c beep.c key.c mq2.c pwm.c timer.c sr04.c oled.c rc522.c as608.c keypad.c flash.c flash.h
  group SYSTEM
    ./SYSTEM/: delay.c uart.c
  group FREERTOS
    ./FreeRTOS/: croutine.c event_groups.c heap_4.c list.c port.c queue.c tasks.c timers.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
